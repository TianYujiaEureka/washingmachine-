# Keil uVision project WIF.uvprojx, settings and files
target WIFI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SFLIB\COMMON_USART;..\SFHW\KEY;..\SFHW\LED;..\SFHW\OLED;..\SFHW\SHT11;..\SFHW\USART;..\SFHW\WIFI;..\SFLIB\delay;..\SFLIB\sys;..\SFLIB\Data;..\SFHW\LED_DISPLAY;..\SFLIB\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SFHW
    ../SFHW/KEY/: key.c
    ../SFHW/LED/: led.c
    ../SFHW/OLED/: oled.c
    ../SFHW/SHT11/: sht11.c
    ../SFHW/WIFI/: WIFI_E103_W02.c
    ../SFHW/USART/: USB_To_Usart.c
    ../SFHW/LED_DISPLAY/: LED_DISPLAY.c
  group SFLIB
    ../SFLIB/COMMON_USART/: CommonUsart.c
    ../SFLIB/delay/: delay.c
    ../SFLIB/sys/: sys.c
    ../SFLIB/Data/: Data_.c
    ../SFLIB/TIMER/: timer.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rtc.c
